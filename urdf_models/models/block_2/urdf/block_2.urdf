Commit message: update urdf files

File: urdf_models/models/block_2/urdf/block_2.urdf (robot description, URDF)
Before this commit: robot block_2, 1 links, 0 joints
Links:
- link my_box: mass 0.4 -> 0.2
